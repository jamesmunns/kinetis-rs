# IAR project sai_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; TWR_K64F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/utilities; ../../../../platform/osa; ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MK64F12; ../../../../platform/hal; ../../../../platform/hal/adc; ../../../../platform/hal/can; ../../../../platform/hal/dac; ../../../../platform/hal/dmamux; ../../../../platform/hal/dspi; ../../../../platform/hal/edma; ../../../../platform/hal/enet; ../../../../platform/hal/flextimer; ../../../../platform/hal/gpio; ../../../../platform/hal/i2c; ../../../../platform/hal/lptmr; ../../../../platform/hal/mcg; ../../../../platform/hal/osc; ../../../../platform/hal/pdb; ../../../../platform/hal/pit; ../../../../platform/hal/pmc; ../../../../platform/hal/port; ../../../../platform/hal/rtc; ../../../../platform/hal/sai; ../../../../platform/hal/sdhc; ../../../../platform/hal/sim; ../../../../platform/hal/smc; ../../../../platform/hal/spi; ../../../../platform/hal/uart; ../../../../platform/hal/wdog; ../../../../platform/drivers; ../../../../platform/drivers/adc; ../../../../platform/drivers/adc/common; ../../../../platform/drivers/can; ../../../../platform/drivers/can/common; ../../../../platform/drivers/edma; ../../../../platform/drivers/edma/common; ../../../../platform/drivers/dac; ../../../../platform/drivers/dac/common; ../../../../platform/drivers/dspi/dspi_master; ../../../../platform/drivers/dspi/dspi_slave; ../../../../platform/drivers/dspi/common; ../../../../platform/drivers/enet; ../../../../platform/drivers/enet/common; ../../../../platform/drivers/enet/src; ../../../../platform/drivers/flash; ../../../../platform/drivers/flextimer; ../../../../platform/drivers/flextimer/common; ../../../../platform/drivers/gpio; ../../../../platform/drivers/gpio/common; ../../../../platform/drivers/i2c/i2c_master; ../../../../platform/drivers/i2c/i2c_slave; ../../../../platform/drivers/i2c/common; ../../../../platform/drivers/lptmr; ../../../../platform/drivers/lptmr/common; ../../../../platform/drivers/mmcau; ../../../../platform/drivers/pdb; ../../../../platform/drivers/pdb/common; ../../../../platform/drivers/pit; ../../../../platform/drivers/pit/common; ../../../../platform/drivers/rtc; ../../../../platform/drivers/rtc/common; ../../../../platform/drivers/sai; ../../../../platform/drivers/sai/common; ../../../../platform/drivers/sdhc; ../../../../platform/drivers/sdhc/common; ../../../../platform/drivers/sdcard; ../../../../platform/drivers/soundcard; ../../../../platform/drivers/spi; ../../../../platform/drivers/spi/common; ../../../../platform/drivers/uart; ../../../../platform/drivers/uart/common; ../../../../platform/drivers/wdog; ../../../../platform/drivers/wdog/common; ../../../../platform/system/clock; ../../../../platform/system/hwtimer; ../../../../platform/system/interrupt; ../../../../platform/system/power; ../../../../boards/common; ../../../../boards/common/sgtl5000; ../../../../boards/common/sgtl5000/src; ../../../../platform/drivers/soundcard; ../../../../platform/drivers/soundcard/src; ../../../../boards/twrk64f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sai_demo.out
  ILINK.IlinkIcfFile: ../../../../platform/linker/iar/K64F12/K64FN1Mxxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/K64F12/debug/ksdk_platform_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; IAR; TWR_K64F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/K64F12/release/ksdk_platform_lib.a
  group startup
    ../../../../platform/startup/MK64F12/iar/: startup_MK64F12.s
    ../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../platform/utilities/src/: fsl_debug_console.c
    ../../../../platform/utilities/: fsl_debug_console.h
  group source
    ../../src/: main.c audio.c audio.h equalizer.c equalizer.h pcm_data.h terminal_menu.c terminal_menu.h
  group codec
    ../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
  group soundcard
    ../../../../platform/drivers/soundcard/src/: fsl_soundcard.c
    ../../../../platform/drivers/soundcard/: fsl_soundcard.h
  group interrupt_handlers
    ../../../../platform/drivers/edma/: fsl_edma_irq.c
    ../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../../platform/drivers/sai/: fsl_sai_irq.c
  group board
    ../../../../boards/twrk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
