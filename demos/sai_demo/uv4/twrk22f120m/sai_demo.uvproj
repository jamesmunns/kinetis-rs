# Keil uVision project sai_demo.uvproj, settings and files
target sai_demo Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: sai_demo.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, ARM_MATH_CM4, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../platform/utilities;../../../../platform/osa;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MK22F51212;../../../../platform/hal;../../../../platform/hal/adc;../../../../platform/hal/can;../../../../platform/hal/dac;../../../../platform/hal/dmamux;../../../../platform/hal/dspi;../../../../platform/hal/edma;../../../../platform/hal/enet;../../../../platform/hal/flextimer;../../../../platform/hal/gpio;../../../../platform/hal/i2c;../../../../platform/hal/lptmr;../../../../platform/hal/lpuart;../../../../platform/hal/mcg;../../../../platform/hal/osc;../../../../platform/hal/pdb;../../../../platform/hal/pit;../../../../platform/hal/pmc;../../../../platform/hal/port;../../../../platform/hal/rtc;../../../../platform/hal/sai;../../../../platform/hal/sdhc;../../../../platform/hal/sim;../../../../platform/hal/smc;../../../../platform/hal/spi;../../../../platform/hal/uart;../../../../platform/hal/wdog;../../../../platform/drivers;../../../../platform/drivers/adc;../../../../platform/drivers/adc/common;../../../../platform/drivers/can;../../../../platform/drivers/can/common;../../../../platform/drivers/edma;../../../../platform/drivers/edma/common;../../../../platform/drivers/dac;../../../../platform/drivers/dac/common;../../../../platform/drivers/dspi/dspi_master;../../../../platform/drivers/dspi/dspi_slave;../../../../platform/drivers/dspi/common;../../../../platform/drivers/enet;../../../../platform/drivers/enet/common;../../../../platform/drivers/enet/src;../../../../platform/drivers/flash;../../../../platform/drivers/flextimer;../../../../platform/drivers/flextimer/common;../../../../platform/drivers/gpio;../../../../platform/drivers/gpio/common;../../../../platform/drivers/i2c/i2c_master;../../../../platform/drivers/i2c/i2c_slave;../../../../platform/drivers/i2c/common;../../../../platform/drivers/lptmr;../../../../platform/drivers/lptmr/common;../../../../platform/drivers/lpuart;../../../../platform/drivers/lpuart/common;../../../../platform/drivers/mmcau;../../../../platform/drivers/pdb;../../../../platform/drivers/pdb/common;../../../../platform/drivers/pit;../../../../platform/drivers/pit/common;../../../../platform/drivers/rtc;../../../../platform/drivers/rtc/common;../../../../platform/drivers/sai;../../../../platform/drivers/sai/common;../../../../platform/drivers/sdhc;../../../../platform/drivers/sdhc/common;../../../../platform/drivers/soundcard;../../../../platform/drivers/spi;../../../../platform/drivers/spi/common;../../../../platform/drivers/uart;../../../../platform/drivers/uart/common;../../../../platform/drivers/wdog;../../../../platform/drivers/wdog/common;../../../../platform/system/clock;../../../../platform/system/hwtimer;../../../../platform/system/interrupt;../../../../platform/system/power;../../../../boards/common;../../../../boards/common/sgtl5000;../../../../boards/common/sgtl5000/src;../../../../platform/drivers/soundcard;../../../../platform/drivers/soundcard/src;../../../../boards/twrk22f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../platform/linker/arm/K22F51212/K22FN512xxx12_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/uv4/K22F51212/debug/ksdk_platform_lib.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib 
--remove
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../platform/startup/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../platform/startup/: startup.c startup.h
  group source
    ../../src/: main.c audio.c audio.h equalizer.c equalizer.h pcm_data.h terminal_menu.c terminal_menu.h
  group codec
    ../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
  group soundcard
    ../../../../platform/drivers/soundcard/src/: fsl_soundcard.c
    ../../../../platform/drivers/soundcard/: fsl_soundcard.h
  group interrupt_handlers
    ../../../../platform/drivers/edma/: fsl_edma_irq.c
    ../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../../platform/drivers/sai/: fsl_sai_irq.c
  group board
    ../../../../boards/twrk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target sai_demo Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: sai_demo.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, ARM_MATH_CM4, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/uv4/K22F51212/release/ksdk_platform_lib.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib 
--remove
