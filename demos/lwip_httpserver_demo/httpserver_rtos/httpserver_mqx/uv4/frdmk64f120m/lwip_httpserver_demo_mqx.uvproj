# Keil uVision project lwip_httpserver_demo_mqx.uvproj, settings and files
target lwip_httpserver_demo_mqx Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: lwip_httpserver_demo_mqx.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_MQX, FRDM_K64F120M, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug;../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/config;../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/bsp;../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/psp;../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/mqx_stdlib;../../../../../../tcpip/lwip;../../../../../../tcpip/lwip/port;../../../../../../tcpip/lwip/port/arch;../../../../../../tcpip/lwip/src;../../../../../../tcpip/lwip/src/include;../../../../../../tcpip/lwip/src/include/ipv4;../../../../../../tcpip/lwip/src/include/ipv4/lwip;../../../../../../tcpip/lwip/src/include/ipv6;../../../../../../tcpip/lwip/src/include/ipv6/lwip;../../../../../../tcpip/lwip/src/include/lwip;../../../../../../tcpip/lwip/src/include/netif;../../../../../../tcpip/lwip/src/include/posix;../../../../../../tcpip/lwip/src/include;../../../../../../platform/utilities;../../../../../../platform/utilities;../../../../../../platform/osa;../../../../../../platform/CMSIS/Include;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/startup/MK64F12;../../../../../../platform/hal;../../../../../../platform/hal/adc;../../../../../../platform/hal/can;../../../../../../platform/hal/dac;../../../../../../platform/hal/dmamux;../../../../../../platform/hal/dspi;../../../../../../platform/hal/edma;../../../../../../platform/hal/enet;../../../../../../platform/hal/flextimer;../../../../../../platform/hal/gpio;../../../../../../platform/hal/i2c;../../../../../../platform/hal/lptmr;../../../../../../platform/hal/mcg;../../../../../../platform/hal/osc;../../../../../../platform/hal/pdb;../../../../../../platform/hal/pit;../../../../../../platform/hal/pmc;../../../../../../platform/hal/port;../../../../../../platform/hal/rtc;../../../../../../platform/hal/sai;../../../../../../platform/hal/sdhc;../../../../../../platform/hal/sim;../../../../../../platform/hal/smc;../../../../../../platform/hal/spi;../../../../../../platform/hal/uart;../../../../../../platform/hal/wdog;../../../../../../platform/drivers;../../../../../../platform/drivers/adc;../../../../../../platform/drivers/adc/common;../../../../../../platform/drivers/can;../../../../../../platform/drivers/can/common;../../../../../../platform/drivers/edma;../../../../../../platform/drivers/edma/common;../../../../../../platform/drivers/dac;../../../../../../platform/drivers/dac/common;../../../../../../platform/drivers/dspi/dspi_master;../../../../../../platform/drivers/dspi/dspi_slave;../../../../../../platform/drivers/dspi/common;../../../../../../platform/drivers/enet;../../../../../../platform/drivers/enet/common;../../../../../../platform/drivers/enet/src;../../../../../../platform/drivers/flash;../../../../../../platform/drivers/flextimer;../../../../../../platform/drivers/flextimer/common;../../../../../../platform/drivers/gpio;../../../../../../platform/drivers/gpio/common;../../../../../../platform/drivers/i2c/i2c_master;../../../../../../platform/drivers/i2c/i2c_slave;../../../../../../platform/drivers/i2c/common;../../../../../../platform/drivers/lptmr;../../../../../../platform/drivers/lptmr/common;../../../../../../platform/drivers/mmcau;../../../../../../platform/drivers/pdb;../../../../../../platform/drivers/pdb/common;../../../../../../platform/drivers/pit;../../../../../../platform/drivers/pit/common;../../../../../../platform/drivers/rtc;../../../../../../platform/drivers/rtc/common;../../../../../../platform/drivers/sai;../../../../../../platform/drivers/sai/common;../../../../../../platform/drivers/sdhc;../../../../../../platform/drivers/sdhc/common;../../../../../../platform/drivers/sdcard;../../../../../../platform/drivers/soundcard;../../../../../../platform/drivers/spi;../../../../../../platform/drivers/spi/common;../../../../../../platform/drivers/uart;../../../../../../platform/drivers/uart/common;../../../../../../platform/drivers/wdog;../../../../../../platform/drivers/wdog/common;../../../../../../platform/system/clock;../../../../../../platform/system/hwtimer;../../../../../../platform/system/interrupt;../../../../../../platform/system/power;../../../../../../boards/common/phyksz8041;../../../../../../boards/frdmk64f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/bsp/K64FN1Mxxx12_flash.scf
  link misc: ../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/bsp/bsp.lib 
../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/psp/psp.lib 
../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/mqx_stdlib/mqx_stdlib.lib 
../../../../../../lib/ksdk_mqx_lib/uv4/K64F12/debug/ksdk_mqx_lib.lib 
../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../../../platform/utilities/: fsl_debug_console.h
  group lwip-port
    ../../../../../../tcpip/lwip/port/arch/: cc.h perf.h
    ../../../../../../tcpip/lwip/port/: ethernetif.c lwipopts.h sys_arch.c
  group lwip-src-api
    ../../../../../../tcpip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../tcpip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c lwip_timers.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../tcpip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-src-core-snmp
    ../../../../../../tcpip/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip-src-include-ipv4
    ../../../../../../tcpip/lwip/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip-src-include-lwip
    ../../../../../../tcpip/lwip/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h tcp_impl.h timers.h udp.h
  group lwip-src-include-netif
    ../../../../../../tcpip/lwip/src/include/netif/: etharp.h ppp_oe.h slipif.h
  group lwip-src-include-posix
    ../../../../../../tcpip/lwip/src/include/posix/: netdb.h
    ../../../../../../tcpip/lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../tcpip/lwip/src/netif/: etharp.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../tcpip/lwip/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h pppdebug.h ppp_impl.h ppp_oe.c randm.c randm.h vj.c vj.h
  group source
    ../../../src/: httpserver-netconn.c httpserver-netconn.h
    ../../../../../../platform/drivers/enet/: fsl_enet_irq.c
    ../../../../../../boards/common/phyksz8041/: fsl_phy_driver.c
  group board
    ../../../../../../boards/frdmk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target lwip_httpserver_demo_mqx Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: lwip_httpserver_demo_mqx.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_MQX, FRDM_K64F120M, FREEDOM
  c misc: as above
  c include: ../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release;../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/config;../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/bsp;../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/psp;../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/mqx_stdlib;../../../../../../tcpip/lwip;../../../../../../tcpip/lwip/port;../../../../../../tcpip/lwip/port/arch;../../../../../../tcpip/lwip/src;../../../../../../tcpip/lwip/src/include;../../../../../../tcpip/lwip/src/include/ipv4;../../../../../../tcpip/lwip/src/include/ipv4/lwip;../../../../../../tcpip/lwip/src/include/ipv6;../../../../../../tcpip/lwip/src/include/ipv6/lwip;../../../../../../tcpip/lwip/src/include/lwip;../../../../../../tcpip/lwip/src/include/netif;../../../../../../tcpip/lwip/src/include/posix;../../../../../../tcpip/lwip/src/include;../../../../../../platform/utilities;../../../../../../platform/utilities;../../../../../../platform/osa;../../../../../../platform/CMSIS/Include;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/startup/MK64F12;../../../../../../platform/hal;../../../../../../platform/hal/adc;../../../../../../platform/hal/can;../../../../../../platform/hal/dac;../../../../../../platform/hal/dmamux;../../../../../../platform/hal/dspi;../../../../../../platform/hal/edma;../../../../../../platform/hal/enet;../../../../../../platform/hal/flextimer;../../../../../../platform/hal/gpio;../../../../../../platform/hal/i2c;../../../../../../platform/hal/lptmr;../../../../../../platform/hal/mcg;../../../../../../platform/hal/osc;../../../../../../platform/hal/pdb;../../../../../../platform/hal/pit;../../../../../../platform/hal/pmc;../../../../../../platform/hal/port;../../../../../../platform/hal/rtc;../../../../../../platform/hal/sai;../../../../../../platform/hal/sdhc;../../../../../../platform/hal/sim;../../../../../../platform/hal/smc;../../../../../../platform/hal/spi;../../../../../../platform/hal/uart;../../../../../../platform/hal/wdog;../../../../../../platform/drivers;../../../../../../platform/drivers/adc;../../../../../../platform/drivers/adc/common;../../../../../../platform/drivers/can;../../../../../../platform/drivers/can/common;../../../../../../platform/drivers/edma;../../../../../../platform/drivers/edma/common;../../../../../../platform/drivers/dac;../../../../../../platform/drivers/dac/common;../../../../../../platform/drivers/dspi/dspi_master;../../../../../../platform/drivers/dspi/dspi_slave;../../../../../../platform/drivers/dspi/common;../../../../../../platform/drivers/enet;../../../../../../platform/drivers/enet/common;../../../../../../platform/drivers/enet/src;../../../../../../platform/drivers/flash;../../../../../../platform/drivers/flextimer;../../../../../../platform/drivers/flextimer/common;../../../../../../platform/drivers/gpio;../../../../../../platform/drivers/gpio/common;../../../../../../platform/drivers/i2c/i2c_master;../../../../../../platform/drivers/i2c/i2c_slave;../../../../../../platform/drivers/i2c/common;../../../../../../platform/drivers/lptmr;../../../../../../platform/drivers/lptmr/common;../../../../../../platform/drivers/mmcau;../../../../../../platform/drivers/pdb;../../../../../../platform/drivers/pdb/common;../../../../../../platform/drivers/pit;../../../../../../platform/drivers/pit/common;../../../../../../platform/drivers/rtc;../../../../../../platform/drivers/rtc/common;../../../../../../platform/drivers/sai;../../../../../../platform/drivers/sai/common;../../../../../../platform/drivers/sdhc;../../../../../../platform/drivers/sdhc/common;../../../../../../platform/drivers/sdcard;../../../../../../platform/drivers/soundcard;../../../../../../platform/drivers/spi;../../../../../../platform/drivers/spi/common;../../../../../../platform/drivers/uart;../../../../../../platform/drivers/uart/common;../../../../../../platform/drivers/wdog;../../../../../../platform/drivers/wdog/common;../../../../../../platform/system/clock;../../../../../../platform/system/hwtimer;../../../../../../platform/system/interrupt;../../../../../../platform/system/power;../../../../../../boards/common/phyksz8041;../../../../../../boards/frdmk64f120m
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/bsp/K64FN1Mxxx12_flash.scf
  link misc: ../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/bsp/bsp.lib 
../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/psp/psp.lib 
../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/mqx_stdlib/mqx_stdlib.lib 
../../../../../../lib/ksdk_mqx_lib/uv4/K64F12/release/ksdk_mqx_lib.lib 
../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove
