# IAR project i2c_rtos_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; IAR; FSL_RTOS_MQX; FRDM_K22F120M; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/config; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/bsp; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/psp; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/mqx_stdlib; ../../../../../platform/utilities; ../../../../../platform/osa; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK22F51212; ../../../../../platform/hal; ../../../../../platform/hal/adc; ../../../../../platform/hal/can; ../../../../../platform/hal/dac; ../../../../../platform/hal/dmamux; ../../../../../platform/hal/dspi; ../../../../../platform/hal/edma; ../../../../../platform/hal/enet; ../../../../../platform/hal/flextimer; ../../../../../platform/hal/gpio; ../../../../../platform/hal/i2c; ../../../../../platform/hal/lptmr; ../../../../../platform/hal/lpuart; ../../../../../platform/hal/mcg; ../../../../../platform/hal/osc; ../../../../../platform/hal/pdb; ../../../../../platform/hal/pit; ../../../../../platform/hal/pmc; ../../../../../platform/hal/port; ../../../../../platform/hal/rtc; ../../../../../platform/hal/sai; ../../../../../platform/hal/sdhc; ../../../../../platform/hal/sim; ../../../../../platform/hal/smc; ../../../../../platform/hal/spi; ../../../../../platform/hal/uart; ../../../../../platform/hal/wdog; ../../../../../platform/drivers; ../../../../../platform/drivers/adc; ../../../../../platform/drivers/adc/common; ../../../../../platform/drivers/can; ../../../../../platform/drivers/can/common; ../../../../../platform/drivers/edma; ../../../../../platform/drivers/edma/common; ../../../../../platform/drivers/dac; ../../../../../platform/drivers/dac/common; ../../../../../platform/drivers/dspi/dspi_master; ../../../../../platform/drivers/dspi/dspi_slave; ../../../../../platform/drivers/dspi/common; ../../../../../platform/drivers/enet; ../../../../../platform/drivers/enet/common; ../../../../../platform/drivers/enet/src; ../../../../../platform/drivers/flash; ../../../../../platform/drivers/flextimer; ../../../../../platform/drivers/flextimer/common; ../../../../../platform/drivers/gpio; ../../../../../platform/drivers/gpio/common; ../../../../../platform/drivers/i2c/i2c_master; ../../../../../platform/drivers/i2c/i2c_slave; ../../../../../platform/drivers/i2c/common; ../../../../../platform/drivers/lptmr; ../../../../../platform/drivers/lptmr/common; ../../../../../platform/drivers/lpuart; ../../../../../platform/drivers/lpuart/common; ../../../../../platform/drivers/mmcau; ../../../../../platform/drivers/pdb; ../../../../../platform/drivers/pdb/common; ../../../../../platform/drivers/pit; ../../../../../platform/drivers/pit/common; ../../../../../platform/drivers/rtc; ../../../../../platform/drivers/rtc/common; ../../../../../platform/drivers/sai; ../../../../../platform/drivers/sai/common; ../../../../../platform/drivers/sdhc; ../../../../../platform/drivers/sdhc/common; ../../../../../platform/drivers/soundcard; ../../../../../platform/drivers/spi; ../../../../../platform/drivers/spi/common; ../../../../../platform/drivers/uart; ../../../../../platform/drivers/uart/common; ../../../../../platform/drivers/wdog; ../../../../../platform/drivers/wdog/common; ../../../../../platform/system/clock; ../../../../../platform/system/hwtimer; ../../../../../platform/system/interrupt; ../../../../../platform/system/power; ../../../src; ../../../../../boards/frdmk22f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_mqx.out
  ILINK.IlinkIcfFile: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/bsp/K22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/bsp/bsp.a; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/psp/psp.a; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/mqx_stdlib/mqx_stdlib.a; ../../../../../lib/ksdk_mqx_lib/iar/K22F51212/debug/ksdk_mqx_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; IAR; FSL_RTOS_MQX; FRDM_K22F120M; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/config; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/bsp; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/psp; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/mqx_stdlib; ../../../../../platform/utilities; ../../../../../platform/osa; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK22F51212; ../../../../../platform/hal; ../../../../../platform/hal/adc; ../../../../../platform/hal/can; ../../../../../platform/hal/dac; ../../../../../platform/hal/dmamux; ../../../../../platform/hal/dspi; ../../../../../platform/hal/edma; ../../../../../platform/hal/enet; ../../../../../platform/hal/flextimer; ../../../../../platform/hal/gpio; ../../../../../platform/hal/i2c; ../../../../../platform/hal/lptmr; ../../../../../platform/hal/lpuart; ../../../../../platform/hal/mcg; ../../../../../platform/hal/osc; ../../../../../platform/hal/pdb; ../../../../../platform/hal/pit; ../../../../../platform/hal/pmc; ../../../../../platform/hal/port; ../../../../../platform/hal/rtc; ../../../../../platform/hal/sai; ../../../../../platform/hal/sdhc; ../../../../../platform/hal/sim; ../../../../../platform/hal/smc; ../../../../../platform/hal/spi; ../../../../../platform/hal/uart; ../../../../../platform/hal/wdog; ../../../../../platform/drivers; ../../../../../platform/drivers/adc; ../../../../../platform/drivers/adc/common; ../../../../../platform/drivers/can; ../../../../../platform/drivers/can/common; ../../../../../platform/drivers/edma; ../../../../../platform/drivers/edma/common; ../../../../../platform/drivers/dac; ../../../../../platform/drivers/dac/common; ../../../../../platform/drivers/dspi/dspi_master; ../../../../../platform/drivers/dspi/dspi_slave; ../../../../../platform/drivers/dspi/common; ../../../../../platform/drivers/enet; ../../../../../platform/drivers/enet/common; ../../../../../platform/drivers/enet/src; ../../../../../platform/drivers/flash; ../../../../../platform/drivers/flextimer; ../../../../../platform/drivers/flextimer/common; ../../../../../platform/drivers/gpio; ../../../../../platform/drivers/gpio/common; ../../../../../platform/drivers/i2c/i2c_master; ../../../../../platform/drivers/i2c/i2c_slave; ../../../../../platform/drivers/i2c/common; ../../../../../platform/drivers/lptmr; ../../../../../platform/drivers/lptmr/common; ../../../../../platform/drivers/lpuart; ../../../../../platform/drivers/lpuart/common; ../../../../../platform/drivers/mmcau; ../../../../../platform/drivers/pdb; ../../../../../platform/drivers/pdb/common; ../../../../../platform/drivers/pit; ../../../../../platform/drivers/pit/common; ../../../../../platform/drivers/rtc; ../../../../../platform/drivers/rtc/common; ../../../../../platform/drivers/sai; ../../../../../platform/drivers/sai/common; ../../../../../platform/drivers/sdhc; ../../../../../platform/drivers/sdhc/common; ../../../../../platform/drivers/soundcard; ../../../../../platform/drivers/spi; ../../../../../platform/drivers/spi/common; ../../../../../platform/drivers/uart; ../../../../../platform/drivers/uart/common; ../../../../../platform/drivers/wdog; ../../../../../platform/drivers/wdog/common; ../../../../../platform/system/clock; ../../../../../platform/system/hwtimer; ../../../../../platform/system/interrupt; ../../../../../platform/system/power; ../../../src; ../../../../../boards/frdmk22f120m
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/bsp/K22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/bsp/bsp.a; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/psp/psp.a; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/mqx_stdlib/mqx_stdlib.a; ../../../../../lib/ksdk_mqx_lib/iar/K22F51212/release/ksdk_mqx_lib.a
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c
    ../../../../../platform/utilities/: fsl_debug_console.h
  group source
    ../../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../src/: i2c_rtos.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../../../../boards/frdmk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
