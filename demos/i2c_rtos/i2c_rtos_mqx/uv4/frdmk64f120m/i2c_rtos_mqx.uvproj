# Keil uVision project i2c_rtos_mqx.uvproj, settings and files
target i2c_rtos_mqx Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: i2c_rtos_mqx.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_MQX, FRDM_K64F120M, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug;../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/config;../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/bsp;../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/psp;../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/mqx_stdlib;../../../../../platform/utilities;../../../../../platform/osa;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MK64F12;../../../../../platform/hal;../../../../../platform/hal/adc;../../../../../platform/hal/can;../../../../../platform/hal/dac;../../../../../platform/hal/dmamux;../../../../../platform/hal/dspi;../../../../../platform/hal/edma;../../../../../platform/hal/enet;../../../../../platform/hal/flextimer;../../../../../platform/hal/gpio;../../../../../platform/hal/i2c;../../../../../platform/hal/lptmr;../../../../../platform/hal/mcg;../../../../../platform/hal/osc;../../../../../platform/hal/pdb;../../../../../platform/hal/pit;../../../../../platform/hal/pmc;../../../../../platform/hal/port;../../../../../platform/hal/rtc;../../../../../platform/hal/sai;../../../../../platform/hal/sdhc;../../../../../platform/hal/sim;../../../../../platform/hal/smc;../../../../../platform/hal/spi;../../../../../platform/hal/uart;../../../../../platform/hal/wdog;../../../../../platform/drivers;../../../../../platform/drivers/adc;../../../../../platform/drivers/adc/common;../../../../../platform/drivers/can;../../../../../platform/drivers/can/common;../../../../../platform/drivers/edma;../../../../../platform/drivers/edma/common;../../../../../platform/drivers/dac;../../../../../platform/drivers/dac/common;../../../../../platform/drivers/dspi/dspi_master;../../../../../platform/drivers/dspi/dspi_slave;../../../../../platform/drivers/dspi/common;../../../../../platform/drivers/enet;../../../../../platform/drivers/enet/common;../../../../../platform/drivers/enet/src;../../../../../platform/drivers/flash;../../../../../platform/drivers/flextimer;../../../../../platform/drivers/flextimer/common;../../../../../platform/drivers/gpio;../../../../../platform/drivers/gpio/common;../../../../../platform/drivers/i2c/i2c_master;../../../../../platform/drivers/i2c/i2c_slave;../../../../../platform/drivers/i2c/common;../../../../../platform/drivers/lptmr;../../../../../platform/drivers/lptmr/common;../../../../../platform/drivers/mmcau;../../../../../platform/drivers/pdb;../../../../../platform/drivers/pdb/common;../../../../../platform/drivers/pit;../../../../../platform/drivers/pit/common;../../../../../platform/drivers/rtc;../../../../../platform/drivers/rtc/common;../../../../../platform/drivers/sai;../../../../../platform/drivers/sai/common;../../../../../platform/drivers/sdhc;../../../../../platform/drivers/sdhc/common;../../../../../platform/drivers/sdcard;../../../../../platform/drivers/soundcard;../../../../../platform/drivers/spi;../../../../../platform/drivers/spi/common;../../../../../platform/drivers/uart;../../../../../platform/drivers/uart/common;../../../../../platform/drivers/wdog;../../../../../platform/drivers/wdog/common;../../../../../platform/system/clock;../../../../../platform/system/hwtimer;../../../../../platform/system/interrupt;../../../../../platform/system/power;../../../src;../../../../../boards/frdmk64f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/bsp/K64FN1Mxxx12_flash.scf
  link misc: ../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/bsp/bsp.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/psp/psp.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/mqx_stdlib/mqx_stdlib.lib 
../../../../../lib/ksdk_mqx_lib/uv4/K64F12/debug/ksdk_mqx_lib.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../rtos/mqx/lib/frdmk64f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../../platform/utilities/: fsl_debug_console.h
  group source
    ../../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../src/: i2c_rtos.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../../../../boards/frdmk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target i2c_rtos_mqx Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: i2c_rtos_mqx.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_MQX, FRDM_K64F120M, FREEDOM
  c misc: as above
  c include: ../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release;../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/config;../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/bsp;../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/psp;../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/mqx_stdlib;../../../../../platform/utilities;../../../../../platform/osa;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MK64F12;../../../../../platform/hal;../../../../../platform/hal/adc;../../../../../platform/hal/can;../../../../../platform/hal/dac;../../../../../platform/hal/dmamux;../../../../../platform/hal/dspi;../../../../../platform/hal/edma;../../../../../platform/hal/enet;../../../../../platform/hal/flextimer;../../../../../platform/hal/gpio;../../../../../platform/hal/i2c;../../../../../platform/hal/lptmr;../../../../../platform/hal/mcg;../../../../../platform/hal/osc;../../../../../platform/hal/pdb;../../../../../platform/hal/pit;../../../../../platform/hal/pmc;../../../../../platform/hal/port;../../../../../platform/hal/rtc;../../../../../platform/hal/sai;../../../../../platform/hal/sdhc;../../../../../platform/hal/sim;../../../../../platform/hal/smc;../../../../../platform/hal/spi;../../../../../platform/hal/uart;../../../../../platform/hal/wdog;../../../../../platform/drivers;../../../../../platform/drivers/adc;../../../../../platform/drivers/adc/common;../../../../../platform/drivers/can;../../../../../platform/drivers/can/common;../../../../../platform/drivers/edma;../../../../../platform/drivers/edma/common;../../../../../platform/drivers/dac;../../../../../platform/drivers/dac/common;../../../../../platform/drivers/dspi/dspi_master;../../../../../platform/drivers/dspi/dspi_slave;../../../../../platform/drivers/dspi/common;../../../../../platform/drivers/enet;../../../../../platform/drivers/enet/common;../../../../../platform/drivers/enet/src;../../../../../platform/drivers/flash;../../../../../platform/drivers/flextimer;../../../../../platform/drivers/flextimer/common;../../../../../platform/drivers/gpio;../../../../../platform/drivers/gpio/common;../../../../../platform/drivers/i2c/i2c_master;../../../../../platform/drivers/i2c/i2c_slave;../../../../../platform/drivers/i2c/common;../../../../../platform/drivers/lptmr;../../../../../platform/drivers/lptmr/common;../../../../../platform/drivers/mmcau;../../../../../platform/drivers/pdb;../../../../../platform/drivers/pdb/common;../../../../../platform/drivers/pit;../../../../../platform/drivers/pit/common;../../../../../platform/drivers/rtc;../../../../../platform/drivers/rtc/common;../../../../../platform/drivers/sai;../../../../../platform/drivers/sai/common;../../../../../platform/drivers/sdhc;../../../../../platform/drivers/sdhc/common;../../../../../platform/drivers/sdcard;../../../../../platform/drivers/soundcard;../../../../../platform/drivers/spi;../../../../../platform/drivers/spi/common;../../../../../platform/drivers/uart;../../../../../platform/drivers/uart/common;../../../../../platform/drivers/wdog;../../../../../platform/drivers/wdog/common;../../../../../platform/system/clock;../../../../../platform/system/hwtimer;../../../../../platform/system/interrupt;../../../../../platform/system/power;../../../src;../../../../../boards/frdmk64f120m
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/bsp/K64FN1Mxxx12_flash.scf
  link misc: ../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/bsp/bsp.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/psp/psp.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/mqx_stdlib/mqx_stdlib.lib 
../../../../../lib/ksdk_mqx_lib/uv4/K64F12/release/ksdk_mqx_lib.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../rtos/mqx/lib/frdmk64f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove
