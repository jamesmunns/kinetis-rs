# IAR project i2c_rtos_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; FSL_RTOS_UCOSIII; FRDM_K64F120M; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../rtos/uCOSIII/src/config; ../../../../../rtos/uCOSIII/src/uCOS-III/Source; ../../../../../rtos/uCOSIII/src/uC-CPU; ../../../../../rtos/uCOSIII/src/uC-LIB; ../../../../../platform/utilities; ../../../../../platform/osa; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK64F12; ../../../../../platform/hal; ../../../../../platform/hal/adc; ../../../../../platform/hal/can; ../../../../../platform/hal/dac; ../../../../../platform/hal/dmamux; ../../../../../platform/hal/dspi; ../../../../../platform/hal/edma; ../../../../../platform/hal/enet; ../../../../../platform/hal/flextimer; ../../../../../platform/hal/gpio; ../../../../../platform/hal/i2c; ../../../../../platform/hal/lptmr; ../../../../../platform/hal/mcg; ../../../../../platform/hal/osc; ../../../../../platform/hal/pdb; ../../../../../platform/hal/pit; ../../../../../platform/hal/pmc; ../../../../../platform/hal/port; ../../../../../platform/hal/rtc; ../../../../../platform/hal/sai; ../../../../../platform/hal/sdhc; ../../../../../platform/hal/sim; ../../../../../platform/hal/smc; ../../../../../platform/hal/spi; ../../../../../platform/hal/uart; ../../../../../platform/hal/wdog; ../../../../../platform/drivers; ../../../../../platform/drivers/adc; ../../../../../platform/drivers/adc/common; ../../../../../platform/drivers/can; ../../../../../platform/drivers/can/common; ../../../../../platform/drivers/edma; ../../../../../platform/drivers/edma/common; ../../../../../platform/drivers/dac; ../../../../../platform/drivers/dac/common; ../../../../../platform/drivers/dspi/dspi_master; ../../../../../platform/drivers/dspi/dspi_slave; ../../../../../platform/drivers/dspi/common; ../../../../../platform/drivers/enet; ../../../../../platform/drivers/enet/common; ../../../../../platform/drivers/enet/src; ../../../../../platform/drivers/flash; ../../../../../platform/drivers/flextimer; ../../../../../platform/drivers/flextimer/common; ../../../../../platform/drivers/gpio; ../../../../../platform/drivers/gpio/common; ../../../../../platform/drivers/i2c/i2c_master; ../../../../../platform/drivers/i2c/i2c_slave; ../../../../../platform/drivers/i2c/common; ../../../../../platform/drivers/lptmr; ../../../../../platform/drivers/lptmr/common; ../../../../../platform/drivers/mmcau; ../../../../../platform/drivers/pdb; ../../../../../platform/drivers/pdb/common; ../../../../../platform/drivers/pit; ../../../../../platform/drivers/pit/common; ../../../../../platform/drivers/rtc; ../../../../../platform/drivers/rtc/common; ../../../../../platform/drivers/sai; ../../../../../platform/drivers/sai/common; ../../../../../platform/drivers/sdhc; ../../../../../platform/drivers/sdhc/common; ../../../../../platform/drivers/sdcard; ../../../../../platform/drivers/soundcard; ../../../../../platform/drivers/spi; ../../../../../platform/drivers/spi/common; ../../../../../platform/drivers/uart; ../../../../../platform/drivers/uart/common; ../../../../../platform/drivers/wdog; ../../../../../platform/drivers/wdog/common; ../../../../../platform/system/clock; ../../../../../platform/system/hwtimer; ../../../../../platform/system/interrupt; ../../../../../platform/system/power; ../../../src; ../../../../../boards/frdmk64f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_ucosiii.out
  ILINK.IlinkIcfFile: ../../../../../platform/linker/iar/K64F12/K64FN1Mxxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_ucosiii_lib/iar/K64F12/debug/ksdk_ucosiii_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; IAR; FSL_RTOS_UCOSIII; FRDM_K64F120M; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_ucosiii_lib/iar/K64F12/release/ksdk_ucosiii_lib.a
  group ucosiii
    ../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR/: cpu_c.c cpu_a.asm
    ../../../../../rtos/uCOSIII/src/config/: os_app_hooks.c
    ../../../../../rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../rtos/uCOSIII/src/uC-CPU/: cpu_core.c
  group startup
    ../../../../../platform/startup/MK64F12/iar/: startup_MK64F12.s
    ../../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c
    ../../../../../platform/utilities/: fsl_debug_console.h
  group source
    ../../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../src/: i2c_rtos.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../../../../boards/frdmk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
