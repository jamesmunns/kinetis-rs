# Keil uVision project i2c_rtos_freertos.uvproj, settings and files
target i2c_rtos_freertos Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: i2c_rtos_freertos.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12, KEIL, FSL_RTOS_FREE_RTOS, FRDM_K22F120M, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../../rtos/FreeRTOS/port/keil;../../../../../rtos/FreeRTOS/config/K22F51212/keil;../../../../../rtos/FreeRTOS/include;../../../../../rtos/FreeRTOS/src;../../../../../platform/utilities;../../../../../platform/osa;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MK22F51212;../../../../../platform/hal;../../../../../platform/hal/adc;../../../../../platform/hal/can;../../../../../platform/hal/dac;../../../../../platform/hal/dmamux;../../../../../platform/hal/dspi;../../../../../platform/hal/edma;../../../../../platform/hal/enet;../../../../../platform/hal/flextimer;../../../../../platform/hal/gpio;../../../../../platform/hal/i2c;../../../../../platform/hal/lptmr;../../../../../platform/hal/lpuart;../../../../../platform/hal/mcg;../../../../../platform/hal/osc;../../../../../platform/hal/pdb;../../../../../platform/hal/pit;../../../../../platform/hal/pmc;../../../../../platform/hal/port;../../../../../platform/hal/rtc;../../../../../platform/hal/sai;../../../../../platform/hal/sdhc;../../../../../platform/hal/sim;../../../../../platform/hal/smc;../../../../../platform/hal/spi;../../../../../platform/hal/uart;../../../../../platform/hal/wdog;../../../../../platform/drivers;../../../../../platform/drivers/adc;../../../../../platform/drivers/adc/common;../../../../../platform/drivers/can;../../../../../platform/drivers/can/common;../../../../../platform/drivers/edma;../../../../../platform/drivers/edma/common;../../../../../platform/drivers/dac;../../../../../platform/drivers/dac/common;../../../../../platform/drivers/dspi/dspi_master;../../../../../platform/drivers/dspi/dspi_slave;../../../../../platform/drivers/dspi/common;../../../../../platform/drivers/enet;../../../../../platform/drivers/enet/common;../../../../../platform/drivers/enet/src;../../../../../platform/drivers/flash;../../../../../platform/drivers/flextimer;../../../../../platform/drivers/flextimer/common;../../../../../platform/drivers/gpio;../../../../../platform/drivers/gpio/common;../../../../../platform/drivers/i2c/i2c_master;../../../../../platform/drivers/i2c/i2c_slave;../../../../../platform/drivers/i2c/common;../../../../../platform/drivers/lptmr;../../../../../platform/drivers/lptmr/common;../../../../../platform/drivers/lpuart;../../../../../platform/drivers/lpuart/common;../../../../../platform/drivers/mmcau;../../../../../platform/drivers/pdb;../../../../../platform/drivers/pdb/common;../../../../../platform/drivers/pit;../../../../../platform/drivers/pit/common;../../../../../platform/drivers/rtc;../../../../../platform/drivers/rtc/common;../../../../../platform/drivers/sai;../../../../../platform/drivers/sai/common;../../../../../platform/drivers/sdhc;../../../../../platform/drivers/sdhc/common;../../../../../platform/drivers/soundcard;../../../../../platform/drivers/spi;../../../../../platform/drivers/spi/common;../../../../../platform/drivers/uart;../../../../../platform/drivers/uart/common;../../../../../platform/drivers/wdog;../../../../../platform/drivers/wdog/common;../../../../../platform/system/clock;../../../../../platform/system/hwtimer;../../../../../platform/system/interrupt;../../../../../platform/system/power;../../../src;../../../../../boards/frdmk22f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../rtos/FreeRTOS/config/K22F51212/keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../platform/linker/arm/K22F51212/K22FN512xxx12_flash.scf
  link misc: ../../../../../lib/ksdk_freertos_lib/uv4/K22F51212/debug/ksdk_freertos_lib.lib 
--remove
  group free-rtos
    ../../../../../rtos/FreeRTOS/port/keil/: port.c portasm.S portmacro.h portTicks.h
    ../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../../platform/startup/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../../platform/startup/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../platform/startup/: startup.c startup.h
  group source
    ../../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../src/: i2c_rtos.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../../../../boards/frdmk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target i2c_rtos_freertos Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: i2c_rtos_freertos.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12, KEIL, FSL_RTOS_FREE_RTOS, FRDM_K22F120M, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../rtos/FreeRTOS/config/K22F51212/keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_freertos_lib/uv4/K22F51212/release/ksdk_freertos_lib.lib 
--remove
