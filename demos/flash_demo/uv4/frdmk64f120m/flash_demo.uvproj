# Keil uVision project flash_demo.uvproj, settings and files
target flash_demo Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: flash_demo.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, FRDM_K64F120M, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../platform/utilities;../../../../platform/osa;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MK64F12;../../../../platform/hal;../../../../platform/hal/adc;../../../../platform/hal/can;../../../../platform/hal/dac;../../../../platform/hal/dmamux;../../../../platform/hal/dspi;../../../../platform/hal/edma;../../../../platform/hal/enet;../../../../platform/hal/flextimer;../../../../platform/hal/gpio;../../../../platform/hal/i2c;../../../../platform/hal/lptmr;../../../../platform/hal/mcg;../../../../platform/hal/osc;../../../../platform/hal/pdb;../../../../platform/hal/pit;../../../../platform/hal/pmc;../../../../platform/hal/port;../../../../platform/hal/rtc;../../../../platform/hal/sai;../../../../platform/hal/sdhc;../../../../platform/hal/sim;../../../../platform/hal/smc;../../../../platform/hal/spi;../../../../platform/hal/uart;../../../../platform/hal/wdog;../../../../platform/drivers;../../../../platform/drivers/adc;../../../../platform/drivers/adc/common;../../../../platform/drivers/can;../../../../platform/drivers/can/common;../../../../platform/drivers/edma;../../../../platform/drivers/edma/common;../../../../platform/drivers/dac;../../../../platform/drivers/dac/common;../../../../platform/drivers/dspi/dspi_master;../../../../platform/drivers/dspi/dspi_slave;../../../../platform/drivers/dspi/common;../../../../platform/drivers/enet;../../../../platform/drivers/enet/common;../../../../platform/drivers/enet/src;../../../../platform/drivers/flash;../../../../platform/drivers/flextimer;../../../../platform/drivers/flextimer/common;../../../../platform/drivers/gpio;../../../../platform/drivers/gpio/common;../../../../platform/drivers/i2c/i2c_master;../../../../platform/drivers/i2c/i2c_slave;../../../../platform/drivers/i2c/common;../../../../platform/drivers/lptmr;../../../../platform/drivers/lptmr/common;../../../../platform/drivers/mmcau;../../../../platform/drivers/pdb;../../../../platform/drivers/pdb/common;../../../../platform/drivers/pit;../../../../platform/drivers/pit/common;../../../../platform/drivers/rtc;../../../../platform/drivers/rtc/common;../../../../platform/drivers/sai;../../../../platform/drivers/sai/common;../../../../platform/drivers/sdhc;../../../../platform/drivers/sdhc/common;../../../../platform/drivers/sdcard;../../../../platform/drivers/soundcard;../../../../platform/drivers/spi;../../../../platform/drivers/spi/common;../../../../platform/drivers/uart;../../../../platform/drivers/uart/common;../../../../platform/drivers/wdog;../../../../platform/drivers/wdog/common;../../../../platform/system/clock;../../../../platform/system/hwtimer;../../../../platform/system/interrupt;../../../../platform/system/power;../../../../platform/drivers/flash/C90TFS/drvsrc/include;../../src;../../../../boards/frdmk64f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../platform/linker/arm/K64F12/K64FN1Mxxx12_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/uv4/K64F12/debug/ksdk_platform_lib.lib 
--remove
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MK64F12/arm/: startup_MK64F12.s
    ../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../platform/startup/: startup.c startup.h
  group source
    ../../src/: flash_demo.c flash_swap.c user_cfg.h
  group flash
    ../../../../platform/drivers/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../platform/drivers/flash/C90TFS/drvsrc/include/: FTFx_CX_(128_64_32)K_32K_2K_1K_1K.h FTFx_CX_256K_32K_2K_1K_1K.h FTFx_DX_(64_48_32_16)K_0K_0K_1K_0K.h FTFx_DX_(256_128_96_64)K_32K_2K_2K_1K.h FTFx_KX_(128_64_32)K_0K_0K_2K_0K.h FTFx_KX_(128_64_32)K_0K_2K_1K_0K.h FTFx_KX_(128_64_32)K_32K_2K_1K_1K.h FTFx_KX_(256_128)K_64K_4K_2K_2K.h FTFx_KX_(256_128_64)K_32K_2K_2K_1K.h FTFx_KX_(256_128_64_32_16_8)K_0K_0K_1K_0K.h FTFx_KX_(512_256)K_0K_4K_2K_0K.h FTFx_KX_128K_128K_4K_2K_2K.h FTFx_KX_256K_256K_4K_2K_2K.h FTFx_KX_512K_128K_4K_4K_4K.h FTFx_KX_512K_512K_16K_4K_4K.h FTFx_KX_1024K_0K_(16_4)K_4K_0K.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group board
    ../../../../boards/frdmk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target flash_demo Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: flash_demo.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, FRDM_K64F120M, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/uv4/K64F12/release/ksdk_platform_lib.lib 
--remove
