# Keil uVision project flash_demo.uvproj, settings and files
target flash_demo Debug (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: flash_demo.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CLOCK_SETUP=0, CPU_MKV31F512VLL12, KEIL, TWR_KV31F120M, TOWER
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../platform/utilities;../../../../platform/osa;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MKV31F51212;../../../../platform/hal;../../../../platform/hal/adc;../../../../platform/hal/can;../../../../platform/hal/dac;../../../../platform/hal/dmamux;../../../../platform/hal/dspi;../../../../platform/hal/edma;../../../../platform/hal/enet;../../../../platform/hal/flextimer;../../../../platform/hal/gpio;../../../../platform/hal/i2c;../../../../platform/hal/lptmr;../../../../platform/hal/lpuart;../../../../platform/hal/mcg;../../../../platform/hal/osc;../../../../platform/hal/pdb;../../../../platform/hal/pit;../../../../platform/hal/pmc;../../../../platform/hal/port;../../../../platform/hal/rtc;../../../../platform/hal/sai;../../../../platform/hal/sdhc;../../../../platform/hal/sim;../../../../platform/hal/smc;../../../../platform/hal/spi;../../../../platform/hal/uart;../../../../platform/hal/wdog;../../../../platform/drivers;../../../../platform/drivers/adc;../../../../platform/drivers/adc/common;../../../../platform/drivers/can;../../../../platform/drivers/can/common;../../../../platform/drivers/edma;../../../../platform/drivers/edma/common;../../../../platform/drivers/dac;../../../../platform/drivers/dac/common;../../../../platform/drivers/dspi/dspi_master;../../../../platform/drivers/dspi/dspi_slave;../../../../platform/drivers/dspi/common;../../../../platform/drivers/enet;../../../../platform/drivers/enet/common;../../../../platform/drivers/enet/src;../../../../platform/drivers/flash;../../../../platform/drivers/flextimer;../../../../platform/drivers/flextimer/common;../../../../platform/drivers/gpio;../../../../platform/drivers/gpio/common;../../../../platform/drivers/i2c/i2c_master;../../../../platform/drivers/i2c/i2c_slave;../../../../platform/drivers/i2c/common;../../../../platform/drivers/lptmr;../../../../platform/drivers/lptmr/common;../../../../platform/drivers/lpuart;../../../../platform/drivers/lpuart/common;../../../../platform/drivers/mmcau;../../../../platform/drivers/pdb;../../../../platform/drivers/pdb/common;../../../../platform/drivers/pit;../../../../platform/drivers/pit/common;../../../../platform/drivers/rtc;../../../../platform/drivers/rtc/common;../../../../platform/drivers/sai;../../../../platform/drivers/sai/common;../../../../platform/drivers/sdhc;../../../../platform/drivers/sdhc/common;../../../../platform/drivers/soundcard;../../../../platform/drivers/spi;../../../../platform/drivers/spi/common;../../../../platform/drivers/uart;../../../../platform/drivers/uart/common;../../../../platform/drivers/wdog;../../../../platform/drivers/wdog/common;../../../../platform/system/clock;../../../../platform/system/hwtimer;../../../../platform/system/interrupt;../../../../platform/system/power;../../../../platform/drivers/flash/C90TFS/drvsrc/include;../../src;../../../../boards/twrkv31f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../platform/linker/arm/KV31F51212/KV31F512xxx12_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/uv4/KV31F51212/debug/ksdk_platform_lib.lib 
--remove
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MKV31F51212/arm/: startup_MKV31F51212.s
    ../../../../platform/startup/MKV31F51212/: system_MKV31F51212.c system_MKV31F51212.h
    ../../../../platform/startup/: startup.c startup.h
  group source
    ../../src/: flash_demo.c flash_swap.c user_cfg.h
  group flash
    ../../../../platform/drivers/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../platform/drivers/flash/C90TFS/drvsrc/include/: FTFx_CX_(128_64_32)K_32K_2K_1K_1K.h FTFx_CX_256K_32K_2K_1K_1K.h FTFx_DX_(64_48_32_16)K_0K_0K_1K_0K.h FTFx_DX_(256_128_96_64)K_32K_2K_2K_1K.h FTFx_KX_(128_64_32)K_0K_0K_2K_0K.h FTFx_KX_(128_64_32)K_0K_2K_1K_0K.h FTFx_KX_(128_64_32)K_32K_2K_1K_1K.h FTFx_KX_(256_128)K_64K_4K_2K_2K.h FTFx_KX_(256_128_64)K_32K_2K_2K_1K.h FTFx_KX_(256_128_64_32_16_8)K_0K_0K_1K_0K.h FTFx_KX_(512_256)K_0K_4K_2K_0K.h FTFx_KX_128K_128K_4K_2K_2K.h FTFx_KX_256K_256K_4K_2K_2K.h FTFx_KX_512K_128K_4K_4K_4K.h FTFx_KX_512K_512K_16K_4K_4K.h FTFx_KX_1024K_0K_(16_4)K_4K_0K.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group board
    ../../../../boards/twrkv31f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target flash_demo Release (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: as above
  output: flash_demo.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CLOCK_SETUP=0, CPU_MKV31F512VLL12, KEIL, TWR_KV31F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/uv4/KV31F51212/release/ksdk_platform_lib.lib 
--remove
