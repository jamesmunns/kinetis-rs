<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/usbd_sdk_frdmk64f120m_mqx.ewp</path>
  </project>
</workspace>
