# IAR project usbh_sdk_frdmk22f120m_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; IAR; FSL_RTOS_UCOSIII
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../../rtos; ../../../../../../rtos/uCOSIII/src/config; ../../../../../../rtos/uCOSIII/src/uCOS-III/Source; ../../../../../../rtos/uCOSIII/src/uC-LIB; ../../../../../../rtos/uCOSIII/src/uC-CPU; ../../../../../adapter/sources; ../../../../../adapter/sources/sdk; ../../../../include; ../../../include; ../../../sources/classes/audio; ../../../sources/classes/cdc; ../../../sources/classes/common; ../../../sources/classes/hid; ../../../sources/classes/hub; ../../../sources/classes/include; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/controller; ../../../sources/controller/khci; ../../../../hal; ../../../../../../platform/include; ../../../../../../platform/osa; ../../../../../../platform/utilities; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/system/clock; ../../../../../../platform/hal/mcg; ../../../../../../platform/hal/sim; ../../../../../../platform/startup/MK22F51212; ../../../../../../platform/CMSIS/Include/device/MK22F51212; ../../../include/frdmk22f120m
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; IAR; FSL_RTOS_UCOSIII
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
  group adapter/sdk
    ../../../../../adapter/sources/sdk/: adapter_cfg.h adapter_sdk.c adapter_sdk.h
  group usb_core/include
    ../../../../include/: compiler.h types.h usb.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group usb_core/host/include
    ../../../include/: usb_host_stack_interface.h
    ../../../include/frdmk22f120m/: usb_host_config.h
  group usb_core/host/sources/class driver/common
    ../../../sources/classes/common/: usb_classes.c
  group usb_core/host/sources/class driver/audio
    ../../../sources/classes/audio/: usb_host_audio.c usb_host_audio.h usb_host_audio_intf.c
  group usb_core/host/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_host_cdc.c usb_host_cdc.h usb_host_cdc_intf.c
  group usb_core/host/sources/class driver/hid
    ../../../sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core/host/sources/class driver/hub
    ../../../sources/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group usb_core/host/sources/class driver/msd
    ../../../sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core/host/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core/host/sources/controller driver
    ../../../sources/controller/: usb_host.c usb_host.h usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h
  group usb_core/host/sources/controller driver/khci
    ../../../sources/controller/khci/: khci.c khci.h khci_prv.h
  group usb_core/host/sources/bsp
    ../../../sources/bsp/frdmk22f120m/: usb_host_bsp.c
