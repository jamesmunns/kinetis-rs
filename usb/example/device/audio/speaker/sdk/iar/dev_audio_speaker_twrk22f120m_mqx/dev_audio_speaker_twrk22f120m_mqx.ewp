# IAR project dev_audio_speaker_twrk22f120m_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VDC12; IAR; TWR_K22F120M; TOWER; FSL_RTOS_MQX
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug/config; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug/bsp; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug/psp; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug/mqx_stdlib; ../../../../../../../../platform/osa; ../../../../../../../../rtos; ../../../../../../../../platform/utilities; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/startup/MK22F51212; ../../../../../../../../boards/twrk22f120m; ../../../../../../../adapter/sources; ../../../../../../../adapter/sources/sdk; ../../../../generator; ../../..; ../..; ../../..; ../../../../../cdc/virtual_com; ../../../../../composite/hid_audio; ../../../../../composite/msd_cdc; ../../../../../hid/hid_keyboard; ../../../../../hid/hid_mouse; ../../../../../msd; ../../../../../phdc/weighscale; ../../../../../../host/audio/speaker; ../../../../../../host/cdc/cdc_serial; ../../../../../../host/cdc/cdc_serial/sdk/serial_bsp; ../../../../../../host/hid/keyboard; ../../../../../../host/hid/keyboard+mouse; ../../../../../../host/hid/mouse; ../../../../../../host/msd/msd_cmd; ../../../../../../host/phdc/11073Manager_Demo; ../../../../../../otg/hid/mouse; ../../../../../../../usb_core/device/include/twrk22f120m; ../../../../../../../usb_core/device/include; ../../../../../../../usb_core/device/sources/classes/audio; ../../../../../../../usb_core/device/sources/classes/cdc; ../../../../../../../usb_core/device/sources/classes/common; ../../../../../../../usb_core/device/sources/classes/composite; ../../../../../../../usb_core/device/sources/classes/hid; ../../../../../../../usb_core/device/sources/classes/include; ../../../../../../../usb_core/device/sources/classes/msd; ../../../../../../../usb_core/device/sources/classes/phdc; ../../../../../../../usb_core/device/sources/controller/khci; ../../../../../../../usb_core/device/sources/controller; ../../../../../../../usb_core/hal; ../../../../../../../usb_core/host/include/twrk22f120m; ../../../../../../../usb_core/host/include; ../../../../../../../usb_core/host/sources/classes/audio; ../../../../../../../usb_core/host/sources/classes/cdc; ../../../../../../../usb_core/host/sources/classes/hid; ../../../../../../../usb_core/host/sources/classes/hub; ../../../../../../../usb_core/host/sources/classes/msd; ../../../../../../../usb_core/host/sources/classes/phdc; ../../../../../../../usb_core/host/sources/classes/printer; ../../../../../../../usb_core/host/sources/controller/khci; ../../../../../../../usb_core/host/sources/controller; ../../../../../../../usb_core/include; ../../../../../../../usb_core/otg/sources/driver/khci; ../../../../../../../usb_core/otg/sources/driver/khci_max3353; ../../../../../../../usb_core/otg/sources/driver/max3353/bm; ../../../../../../../usb_core/otg/sources/driver/max3353/mqx; ../../../../../../../usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../usb_core/otg/sources/include; ../../../../../../../usb_core/otg/sources/otg; ../../../../../../../../platform/drivers/uart; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/gpio; ../../../../../../../../platform/drivers/pit; ../../../../../../../../platform/hal/gpio; ../../../../../../../../platform/drivers/lpuart; ../../../../../../../../platform/drivers/lpuart/common; ../../../../../../../../platform/system/clock; ../../../../../../../../platform/hal/port; ../../../../../../../../platform/hal/uart; ../../../../../../../../platform/hal/pit; ../../../../../../../../platform/hal/lpuart; ../../../../../../../../platform/drivers/edma; ../../../../../../../../platform/drivers/edma/common; ../../../../../../../../platform/hal/edma; ../../../../../../../../platform/hal/dmamux; ../../../../../../../../platform/hal/mcg; ../../../../../../../../platform/hal/sim; ../../../../../../../../boards/common/sgtl5000; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/soundcard; ../../../../../../../../platform/drivers/sai; ../../../../../../../../platform/drivers/sai/common; ../../../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../../../platform/drivers/i2c/common; ../../../../../../../../platform/hal/sai; ../../../../../../../../platform/hal/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_audio_speaker_mqx.out
  ILINK.IlinkIcfFile: ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug/bsp/K22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug/bsp/bsp.a; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug/psp/psp.a; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/debug/mqx_stdlib/mqx_stdlib.a; ../../../../../../../../lib/ksdk_mqx_lib/iar/K22F51212/debug/ksdk_mqx_lib.a; ../../../../../../../usb_core/device/build/iar/usbd_sdk_twrk22f120m_mqx/debug/usbd_mqx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VDC12; IAR; TWR_K22F120M; TOWER; FSL_RTOS_MQX
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release/config; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release/bsp; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release/psp; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release/mqx_stdlib; ../../../../../../../../platform/osa; ../../../../../../../../rtos; ../../../../../../../../platform/utilities; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/startup/MK22F51212; ../../../../../../../../boards/twrk22f120m; ../../../../../../../adapter/sources; ../../../../../../../adapter/sources/sdk; ../../../../generator; ../../..; ../..; ../../..; ../../../../../cdc/virtual_com; ../../../../../composite/hid_audio; ../../../../../composite/msd_cdc; ../../../../../hid/hid_keyboard; ../../../../../hid/hid_mouse; ../../../../../msd; ../../../../../phdc/weighscale; ../../../../../../host/audio/speaker; ../../../../../../host/cdc/cdc_serial; ../../../../../../host/cdc/cdc_serial/sdk/serial_bsp; ../../../../../../host/hid/keyboard; ../../../../../../host/hid/keyboard+mouse; ../../../../../../host/hid/mouse; ../../../../../../host/msd/msd_cmd; ../../../../../../host/phdc/11073Manager_Demo; ../../../../../../otg/hid/mouse; ../../../../../../../usb_core/device/include/twrk22f120m; ../../../../../../../usb_core/device/include; ../../../../../../../usb_core/device/sources/classes/audio; ../../../../../../../usb_core/device/sources/classes/cdc; ../../../../../../../usb_core/device/sources/classes/common; ../../../../../../../usb_core/device/sources/classes/composite; ../../../../../../../usb_core/device/sources/classes/hid; ../../../../../../../usb_core/device/sources/classes/include; ../../../../../../../usb_core/device/sources/classes/msd; ../../../../../../../usb_core/device/sources/classes/phdc; ../../../../../../../usb_core/device/sources/controller/khci; ../../../../../../../usb_core/device/sources/controller; ../../../../../../../usb_core/hal; ../../../../../../../usb_core/host/include/twrk22f120m; ../../../../../../../usb_core/host/include; ../../../../../../../usb_core/host/sources/classes/audio; ../../../../../../../usb_core/host/sources/classes/cdc; ../../../../../../../usb_core/host/sources/classes/hid; ../../../../../../../usb_core/host/sources/classes/hub; ../../../../../../../usb_core/host/sources/classes/msd; ../../../../../../../usb_core/host/sources/classes/phdc; ../../../../../../../usb_core/host/sources/classes/printer; ../../../../../../../usb_core/host/sources/controller/khci; ../../../../../../../usb_core/host/sources/controller; ../../../../../../../usb_core/include; ../../../../../../../usb_core/otg/sources/driver/khci; ../../../../../../../usb_core/otg/sources/driver/khci_max3353; ../../../../../../../usb_core/otg/sources/driver/max3353/bm; ../../../../../../../usb_core/otg/sources/driver/max3353/mqx; ../../../../../../../usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../usb_core/otg/sources/include; ../../../../../../../usb_core/otg/sources/otg; ../../../../../../../../platform/drivers/uart; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/gpio; ../../../../../../../../platform/drivers/pit; ../../../../../../../../platform/hal/gpio; ../../../../../../../../platform/drivers/lpuart; ../../../../../../../../platform/drivers/lpuart/common; ../../../../../../../../platform/system/clock; ../../../../../../../../platform/hal/port; ../../../../../../../../platform/hal/uart; ../../../../../../../../platform/hal/pit; ../../../../../../../../platform/hal/lpuart; ../../../../../../../../platform/drivers/edma; ../../../../../../../../platform/drivers/edma/common; ../../../../../../../../platform/hal/edma; ../../../../../../../../platform/hal/dmamux; ../../../../../../../../platform/hal/mcg; ../../../../../../../../platform/hal/sim; ../../../../../../../../boards/common/sgtl5000; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/soundcard; ../../../../../../../../platform/drivers/sai; ../../../../../../../../platform/drivers/sai/common; ../../../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../../../platform/drivers/i2c/common; ../../../../../../../../platform/hal/sai; ../../../../../../../../platform/hal/i2c
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release/bsp/K22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release/bsp/bsp.a; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release/psp/psp.a; ../../../../../../../../rtos/mqx/lib/twrk22f120m.iar/release/mqx_stdlib/mqx_stdlib.a; ../../../../../../../../lib/ksdk_mqx_lib/iar/K22F51212/release/ksdk_mqx_lib.a; ../../../../../../../usb_core/device/build/iar/usbd_sdk_twrk22f120m_mqx/release/usbd_mqx.a
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_debug_console.c
    ../../../../../../../../platform/utilities/: fsl_debug_console.h
  group board
    ../../../../../../../../boards/twrk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group isr
    ../../../../../../../../platform/drivers/edma/: fsl_edma_irq.c
    ../../../../../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../../../../../../platform/drivers/sai/: fsl_sai_irq.c
  group sources
    ../../../: usb_request.h usb_request.c usb_descriptor.h usb_descriptor.c audio_speaker.h audio_speaker.c
  group sources/soundcard
    ../../../../../../../../platform/drivers/soundcard/src/: fsl_soundcard.c
  group sources/codec
    ../../../../../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
