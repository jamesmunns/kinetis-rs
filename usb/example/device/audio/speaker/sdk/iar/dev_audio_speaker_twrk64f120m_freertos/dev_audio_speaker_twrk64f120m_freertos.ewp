# IAR project dev_audio_speaker_twrk64f120m_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; TWR_K64F120M; TOWER; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/FreeRTOS/config/K64F12/iar; ../../../../../../../../rtos/FreeRTOS/port/iar; ../../../../../../../../platform/osa; ../../../../../../../../rtos; ../../../../../../../../platform/utilities; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/startup/MK64F12; ../../../../../../../../boards/twrk64f120m; ../../../../../../../adapter/sources; ../../../../../../../adapter/sources/sdk; ../../../../generator; ../../..; ../..; ../../..; ../../../../../cdc/virtual_com; ../../../../../composite/hid_audio; ../../../../../composite/msd_cdc; ../../../../../hid/hid_keyboard; ../../../../../hid/hid_mouse; ../../../../../msd; ../../../../../phdc/weighscale; ../../../../../../host/audio/speaker; ../../../../../../host/cdc/cdc_serial; ../../../../../../host/cdc/cdc_serial/sdk/serial_bsp; ../../../../../../host/hid/keyboard; ../../../../../../host/hid/keyboard+mouse; ../../../../../../host/hid/mouse; ../../../../../../host/msd/msd_cmd; ../../../../../../host/phdc/11073Manager_Demo; ../../../../../../otg/hid/mouse; ../../../../../../../usb_core/device/include/twrk64f120m; ../../../../../../../usb_core/device/include; ../../../../../../../usb_core/device/sources/classes/audio; ../../../../../../../usb_core/device/sources/classes/cdc; ../../../../../../../usb_core/device/sources/classes/common; ../../../../../../../usb_core/device/sources/classes/composite; ../../../../../../../usb_core/device/sources/classes/hid; ../../../../../../../usb_core/device/sources/classes/include; ../../../../../../../usb_core/device/sources/classes/msd; ../../../../../../../usb_core/device/sources/classes/phdc; ../../../../../../../usb_core/device/sources/controller/khci; ../../../../../../../usb_core/device/sources/controller; ../../../../../../../usb_core/hal; ../../../../../../../usb_core/host/include/twrk64f120m; ../../../../../../../usb_core/host/include; ../../../../../../../usb_core/host/sources/classes/audio; ../../../../../../../usb_core/host/sources/classes/cdc; ../../../../../../../usb_core/host/sources/classes/hid; ../../../../../../../usb_core/host/sources/classes/hub; ../../../../../../../usb_core/host/sources/classes/msd; ../../../../../../../usb_core/host/sources/classes/phdc; ../../../../../../../usb_core/host/sources/classes/printer; ../../../../../../../usb_core/host/sources/controller/khci; ../../../../../../../usb_core/host/sources/controller; ../../../../../../../usb_core/include; ../../../../../../../usb_core/otg/sources/driver/khci; ../../../../../../../usb_core/otg/sources/driver/khci_max3353; ../../../../../../../usb_core/otg/sources/driver/max3353/bm; ../../../../../../../usb_core/otg/sources/driver/max3353/mqx; ../../../../../../../usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../usb_core/otg/sources/include; ../../../../../../../usb_core/otg/sources/otg; ../../../../../../../../platform/drivers/uart; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/gpio; ../../../../../../../../platform/drivers/pit; ../../../../../../../../platform/hal/gpio; ../../../../../../../../platform/system/clock; ../../../../../../../../platform/hal/port; ../../../../../../../../platform/hal/uart; ../../../../../../../../platform/hal/pit; ../../../../../../../../platform/drivers/edma; ../../../../../../../../platform/drivers/edma/common; ../../../../../../../../platform/hal/edma; ../../../../../../../../platform/hal/dmamux; ../../../../../../../../platform/hal/mcg; ../../../../../../../../platform/hal/sim; ../../../../../../../../rtos/FreeRTOS/include; ../../../../../../../../rtos/FreeRTOS/src; ../../../../../../../../boards/common/sgtl5000; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/soundcard; ../../../../../../../../platform/drivers/sai; ../../../../../../../../platform/drivers/sai/common; ../../../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../../../platform/drivers/i2c/common; ../../../../../../../../platform/hal/sai; ../../../../../../../../platform/hal/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../../rtos/FreeRTOS/config/K64F12/iar
  ILINK.IlinkOutputFile: dev_audio_speaker_freertos.out
  ILINK.IlinkIcfFile: ../../../../../../../../platform/linker/iar/K64F12/K64FN1Mxxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_freertos_lib/iar/K64F12/debug/ksdk_freertos_lib.a; ../../../../../../../usb_core/device/build/iar/usbd_sdk_twrk64f120m_freertos/debug/usbd_freertos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; IAR; TWR_K64F120M; TOWER; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_freertos_lib/iar/K64F12/release/ksdk_freertos_lib.a; ../../../../../../../usb_core/device/build/iar/usbd_sdk_twrk64f120m_freertos/release/usbd_freertos.a
  group free-rtos
    ../../../../../../../../rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
    ../../../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group startup
    ../../../../../../../../platform/startup/MK64F12/iar/: startup_MK64F12.s
    ../../../../../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_debug_console.c
    ../../../../../../../../platform/utilities/: fsl_debug_console.h
  group board
    ../../../../../../../../boards/twrk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group isr
    ../../../../../../../../platform/drivers/edma/: fsl_edma_irq.c
    ../../../../../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../../../../../../platform/drivers/sai/: fsl_sai_irq.c
  group sources
    ../../../: usb_request.h usb_request.c usb_descriptor.h usb_descriptor.c audio_speaker.h audio_speaker.c
  group sources/soundcard
    ../../../../../../../../platform/drivers/soundcard/src/: fsl_soundcard.c
  group sources/codec
    ../../../../../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
