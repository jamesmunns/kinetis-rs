<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>bsp_frdmk22f120m</project><configuration>Debug</configuration></member><member><project>psp_frdmk22f120m</project><configuration>Debug</configuration></member><member><project>mqx_stdlib_frdmk22f120m</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>usbd_sdk_frdmk22f120m_mqx</project><configuration>Debug</configuration></member><member><project>dev_audio_generator_frdmk22f120m_mqx</project><configuration>Debug</configuration></member><member><project>bsp_frdmk22f120m</project><configuration>Release</configuration></member><member><project>psp_frdmk22f120m</project><configuration>Release</configuration></member><member><project>mqx_stdlib_frdmk22f120m</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>usbd_sdk_frdmk22f120m_mqx</project><configuration>Release</configuration></member><member><project>dev_audio_generator_frdmk22f120m_mqx</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_frdmk22f120m</project><configuration>Debug</configuration></member><member><project>psp_frdmk22f120m</project><configuration>Debug</configuration></member><member><project>mqx_stdlib_frdmk22f120m</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>usbd_sdk_frdmk22f120m_mqx</project><configuration>Debug</configuration></member><member><project>dev_audio_generator_frdmk22f120m_mqx</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_frdmk22f120m</project><configuration>Release</configuration></member><member><project>psp_frdmk22f120m</project><configuration>Release</configuration></member><member><project>mqx_stdlib_frdmk22f120m</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>usbd_sdk_frdmk22f120m_mqx</project><configuration>Release</configuration></member><member><project>dev_audio_generator_frdmk22f120m_mqx</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../rtos/mqx/mqx/build/iar/bsp_frdmk22f120m/bsp_frdmk22f120m.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../rtos/mqx/mqx/build/iar/psp_frdmk22f120m/psp_frdmk22f120m.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../rtos/mqx/mqx_stdlib/build/iar/mqx_stdlib_frdmk22f120m/mqx_stdlib_frdmk22f120m.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../lib/ksdk_mqx_lib/iar/K22F51212/ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/../../../../../../../usb_core/device/build/iar/usbd_sdk_frdmk22f120m_mqx/usbd_sdk_frdmk22f120m_mqx.ewp</path></project><project><path>$WS_DIR$/dev_audio_generator_frdmk22f120m_mqx.ewp</path></project></workspace>
