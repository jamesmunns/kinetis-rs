# Keil uVision project dev_audio_generator_frdmk64f120m_bm.uvproj, settings and files
target dev_audio_generator_frdmk64f120m_bm Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: dev_audio_generator_bm.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, FRDM_K64F120M, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../../../../../platform/osa;../../../../../../../../rtos;../../../../../../../../platform/utilities;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK64F12;../../../../../../../../boards/frdmk64f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../..;../../../../speaker;../../../../speaker/sdk;../../../../speaker;../../../../../cdc/virtual_com;../../../../../composite/hid_audio;../../../../../composite/msd_cdc;../../../../../hid/hid_keyboard;../../../../../hid/hid_mouse;../../../../../msd;../../../../../phdc/weighscale;../../../../../../host/audio/speaker;../../../../../../host/cdc/cdc_serial;../../../../../../host/cdc/cdc_serial/sdk/serial_bsp;../../../../../../host/hid/keyboard;../../../../../../host/hid/keyboard+mouse;../../../../../../host/hid/mouse;../../../../../../host/msd/msd_cmd;../../../../../../host/phdc/11073Manager_Demo;../../../../../../otg/hid/mouse;../../../../../../../usb_core/device/include/frdmk64f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/frdmk64f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/khci_max3353;../../../../../../../usb_core/otg/sources/driver/max3353/bm;../../../../../../../usb_core/otg/sources/driver/max3353/mqx;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/drivers/uart;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/gpio;../../../../../../../../platform/drivers/pit;../../../../../../../../platform/hal/gpio;../../../../../../../../platform/system/clock;../../../../../../../../platform/hal/port;../../../../../../../../platform/hal/uart;../../../../../../../../platform/hal/pit;../../../../../../../../platform/drivers/edma;../../../../../../../../platform/drivers/edma/common;../../../../../../../../platform/hal/edma;../../../../../../../../platform/hal/dmamux;../../../../../../../../platform/hal/mcg;../../../../../../../../platform/hal/sim;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/soundcard
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../../../platform/linker/arm/K64F12/K64FN1Mxxx12_flash.scf
  link misc: ../../../../../../../../lib/ksdk_platform_lib/uv4/K64F12/debug/ksdk_platform_lib.lib 
../../../../../../../usb_core/device/build/uv4/usbd_sdk_frdmk64f120m_bm/debug/usbd_bm.lib 
--remove
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../../../../../platform/startup/MK64F12/arm/: startup_MK64F12.s
    ../../../../../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../../../../../platform/startup/: startup.c startup.h
  group board
    ../../../../../../../../boards/frdmk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: audio_data.c audio_generator.c audio_generator.h usb_descriptor.c usb_descriptor.h usb_request.c usb_request.h
target dev_audio_generator_frdmk64f120m_bm Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: dev_audio_generator_bm.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, FRDM_K64F120M, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../../../../../lib/ksdk_platform_lib/uv4/K64F12/release/ksdk_platform_lib.lib 
../../../../../../../usb_core/device/build/uv4/usbd_sdk_frdmk64f120m_bm/release/usbd_bm.lib 
--remove
