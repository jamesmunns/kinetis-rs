<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../rtos/mqx/mqx/build/uv4/bsp_twrk22f120m/bsp_twrk22f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../rtos/mqx/mqx/build/uv4/psp_twrk22f120m/psp_twrk22f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../rtos/mqx/mqx_stdlib/build/uv4/mqx_stdlib_twrk22f120m/mqx_stdlib_twrk22f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../lib/ksdk_mqx_lib/uv4/K22F51212/ksdk_mqx_lib.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../usb_core/device/build/uv4/usbd_sdk_twrk22f120m_mqx/usbd_sdk_twrk22f120m_mqx.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>dev_hid_keyboard_twrk22f120m_mqx.uvproj</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
