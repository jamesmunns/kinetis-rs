# Keil uVision project otg_hid_mouse_twrk64f120m_mqx.uvproj, settings and files
target otg_hid_mouse_twrk64f120m_mqx Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: otg_hid_mouse_mqx.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, TWR_K64F120M, TOWER, FSL_RTOS_MQX, USBCFG_OTG
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug;../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/config;../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/bsp;../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/psp;../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/mqx_stdlib;../../../../../../../../platform/osa;../../../../../../../../rtos;../../../../../../../../platform/utilities;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK64F12;../../../../../../../../boards/twrk64f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../../../device/audio/generator;../../../../../../device/audio/speaker;../../../../../../device/audio/speaker/sdk;../../../../../../device/audio/speaker;../../../../../../device/cdc/virtual_com;../../../../../../device/composite/hid_audio;../../../../../../device/composite/msd_cdc;../../../../../../device/hid/hid_keyboard;../../../../../../device/hid/hid_mouse;../../../../../../device/msd;../../../../../../device/phdc/weighscale;../../../../../../host/audio/speaker;../../../../../../host/cdc/cdc_serial;../../../../../../host/cdc/cdc_serial/sdk/serial_bsp;../../../../../../host/hid/keyboard;../../../../../../host/hid/keyboard+mouse;../../../../../../host/hid/mouse;../../../../../../host/msd/msd_cmd;../../../../../../host/phdc/11073Manager_Demo;../../..;../../../../../../../usb_core/device/include/twrk64f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk64f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/khci_max3353;../../../../../../../usb_core/otg/sources/driver/max3353/bm;../../../../../../../usb_core/otg/sources/driver/max3353/mqx;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/drivers/uart;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/gpio;../../../../../../../../platform/drivers/pit;../../../../../../../../platform/hal/gpio;../../../../../../../../platform/system/clock;../../../../../../../../platform/hal/port;../../../../../../../../platform/hal/uart;../../../../../../../../platform/hal/pit;../../../../../../../../platform/drivers/edma;../../../../../../../../platform/drivers/edma/common;../../../../../../../../platform/hal/edma;../../../../../../../../platform/hal/dmamux;../../../../../../../../platform/hal/mcg;../../../../../../../../platform/hal/sim;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/drivers;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/soundcard;../../../../../../../../platform/drivers/sai;../../../../../../../../platform/drivers/sai/common;../../../../../../../../platform/drivers/i2c/i2c_master;../../../../../../../../platform/drivers/i2c/common;../../../../../../../../platform/hal/sai;../../../../../../../../platform/hal/i2c
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/bsp/K64FN1Mxxx12_flash.scf
  link misc: ../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/bsp/bsp.lib 
../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/psp/psp.lib 
../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/mqx_stdlib/mqx_stdlib.lib 
../../../../../../../../lib/ksdk_mqx_lib/uv4/K64F12/debug/ksdk_mqx_lib.lib 
../../../../../../../usb_core/otg/build/uv4/usbotg_sdk_twrk64f120m_mqx/debug/usbotg_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../../../../../platform/utilities/: fsl_debug_console.h
  group board
    ../../../../../../../../boards/twrk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: dev_mouse.c dev_mouse.h dev_mouse_api.h host_mouse.c host_mouse.h host_mouse_api.h otg_mouse.c otg_mouse.h usb_descriptor.c usb_descriptor.h
target otg_hid_mouse_twrk64f120m_mqx Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: otg_hid_mouse_mqx.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, TWR_K64F120M, TOWER, FSL_RTOS_MQX, USBCFG_OTG
  c misc: as above
  c include: ../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release;../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/config;../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/bsp;../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/psp;../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/mqx_stdlib;../../../../../../../../platform/osa;../../../../../../../../rtos;../../../../../../../../platform/utilities;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK64F12;../../../../../../../../boards/twrk64f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../../../device/audio/generator;../../../../../../device/audio/speaker;../../../../../../device/audio/speaker/sdk;../../../../../../device/audio/speaker;../../../../../../device/cdc/virtual_com;../../../../../../device/composite/hid_audio;../../../../../../device/composite/msd_cdc;../../../../../../device/hid/hid_keyboard;../../../../../../device/hid/hid_mouse;../../../../../../device/msd;../../../../../../device/phdc/weighscale;../../../../../../host/audio/speaker;../../../../../../host/cdc/cdc_serial;../../../../../../host/cdc/cdc_serial/sdk/serial_bsp;../../../../../../host/hid/keyboard;../../../../../../host/hid/keyboard+mouse;../../../../../../host/hid/mouse;../../../../../../host/msd/msd_cmd;../../../../../../host/phdc/11073Manager_Demo;../../..;../../../../../../../usb_core/device/include/twrk64f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk64f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/khci_max3353;../../../../../../../usb_core/otg/sources/driver/max3353/bm;../../../../../../../usb_core/otg/sources/driver/max3353/mqx;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/drivers/uart;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/gpio;../../../../../../../../platform/drivers/pit;../../../../../../../../platform/hal/gpio;../../../../../../../../platform/system/clock;../../../../../../../../platform/hal/port;../../../../../../../../platform/hal/uart;../../../../../../../../platform/hal/pit;../../../../../../../../platform/drivers/edma;../../../../../../../../platform/drivers/edma/common;../../../../../../../../platform/hal/edma;../../../../../../../../platform/hal/dmamux;../../../../../../../../platform/hal/mcg;../../../../../../../../platform/hal/sim;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/drivers;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/soundcard;../../../../../../../../platform/drivers/sai;../../../../../../../../platform/drivers/sai/common;../../../../../../../../platform/drivers/i2c/i2c_master;../../../../../../../../platform/drivers/i2c/common;../../../../../../../../platform/hal/sai;../../../../../../../../platform/hal/i2c
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/bsp/K64FN1Mxxx12_flash.scf
  link misc: ../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/bsp/bsp.lib 
../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/psp/psp.lib 
../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/mqx_stdlib/mqx_stdlib.lib 
../../../../../../../../lib/ksdk_mqx_lib/uv4/K64F12/release/ksdk_mqx_lib.lib 
../../../../../../../usb_core/otg/build/uv4/usbotg_sdk_twrk64f120m_mqx/release/usbotg_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../../../rtos/mqx/lib/twrk64f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove
