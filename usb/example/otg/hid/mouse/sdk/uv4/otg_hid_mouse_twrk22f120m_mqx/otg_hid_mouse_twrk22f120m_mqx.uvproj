# Keil uVision project otg_hid_mouse_twrk22f120m_mqx.uvproj, settings and files
target otg_hid_mouse_twrk22f120m_mqx Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: otg_hid_mouse_mqx.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER, FSL_RTOS_MQX, USBCFG_OTG
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug;../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/config;../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/bsp;../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/psp;../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/mqx_stdlib;../../../../../../../../platform/osa;../../../../../../../../rtos;../../../../../../../../platform/utilities;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK22F51212;../../../../../../../../boards/twrk22f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../../../device/audio/generator;../../../../../../device/audio/speaker;../../../../../../device/audio/speaker/sdk;../../../../../../device/audio/speaker;../../../../../../device/cdc/virtual_com;../../../../../../device/composite/hid_audio;../../../../../../device/composite/msd_cdc;../../../../../../device/hid/hid_keyboard;../../../../../../device/hid/hid_mouse;../../../../../../device/msd;../../../../../../device/phdc/weighscale;../../../../../../host/audio/speaker;../../../../../../host/cdc/cdc_serial;../../../../../../host/cdc/cdc_serial/sdk/serial_bsp;../../../../../../host/hid/keyboard;../../../../../../host/hid/keyboard+mouse;../../../../../../host/hid/mouse;../../../../../../host/msd/msd_cmd;../../../../../../host/phdc/11073Manager_Demo;../../..;../../../../../../../usb_core/device/include/twrk22f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk22f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/khci_max3353;../../../../../../../usb_core/otg/sources/driver/max3353/bm;../../../../../../../usb_core/otg/sources/driver/max3353/mqx;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/drivers/uart;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/gpio;../../../../../../../../platform/drivers/pit;../../../../../../../../platform/hal/gpio;../../../../../../../../platform/drivers/lpuart;../../../../../../../../platform/drivers/lpuart/common;../../../../../../../../platform/system/clock;../../../../../../../../platform/hal/port;../../../../../../../../platform/hal/uart;../../../../../../../../platform/hal/pit;../../../../../../../../platform/hal/lpuart;../../../../../../../../platform/drivers/edma;../../../../../../../../platform/drivers/edma/common;../../../../../../../../platform/hal/edma;../../../../../../../../platform/hal/dmamux;../../../../../../../../platform/hal/mcg;../../../../../../../../platform/hal/sim;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/drivers;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/soundcard;../../../../../../../../platform/drivers/sai;../../../../../../../../platform/drivers/sai/common;../../../../../../../../platform/drivers/i2c/i2c_master;../../../../../../../../platform/drivers/i2c/common;../../../../../../../../platform/hal/sai;../../../../../../../../platform/hal/i2c
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/bsp/K22FN512xxx12_flash.scf
  link misc: ../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/bsp/bsp.lib 
../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/psp/psp.lib 
../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/mqx_stdlib/mqx_stdlib.lib 
../../../../../../../../lib/ksdk_mqx_lib/uv4/K22F51212/debug/ksdk_mqx_lib.lib 
../../../../../../../usb_core/otg/build/uv4/usbotg_sdk_twrk22f120m_mqx/debug/usbotg_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../../../../../platform/utilities/: fsl_debug_console.h
  group board
    ../../../../../../../../boards/twrk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: dev_mouse.c dev_mouse.h dev_mouse_api.h host_mouse.c host_mouse.h host_mouse_api.h otg_mouse.c otg_mouse.h usb_descriptor.c usb_descriptor.h
target otg_hid_mouse_twrk22f120m_mqx Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: otg_hid_mouse_mqx.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER, FSL_RTOS_MQX, USBCFG_OTG
  c misc: as above
  c include: ../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release;../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/config;../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/bsp;../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/psp;../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/mqx_stdlib;../../../../../../../../platform/osa;../../../../../../../../rtos;../../../../../../../../platform/utilities;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK22F51212;../../../../../../../../boards/twrk22f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../../../device/audio/generator;../../../../../../device/audio/speaker;../../../../../../device/audio/speaker/sdk;../../../../../../device/audio/speaker;../../../../../../device/cdc/virtual_com;../../../../../../device/composite/hid_audio;../../../../../../device/composite/msd_cdc;../../../../../../device/hid/hid_keyboard;../../../../../../device/hid/hid_mouse;../../../../../../device/msd;../../../../../../device/phdc/weighscale;../../../../../../host/audio/speaker;../../../../../../host/cdc/cdc_serial;../../../../../../host/cdc/cdc_serial/sdk/serial_bsp;../../../../../../host/hid/keyboard;../../../../../../host/hid/keyboard+mouse;../../../../../../host/hid/mouse;../../../../../../host/msd/msd_cmd;../../../../../../host/phdc/11073Manager_Demo;../../..;../../../../../../../usb_core/device/include/twrk22f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk22f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/khci_max3353;../../../../../../../usb_core/otg/sources/driver/max3353/bm;../../../../../../../usb_core/otg/sources/driver/max3353/mqx;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/drivers/uart;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/gpio;../../../../../../../../platform/drivers/pit;../../../../../../../../platform/hal/gpio;../../../../../../../../platform/drivers/lpuart;../../../../../../../../platform/drivers/lpuart/common;../../../../../../../../platform/system/clock;../../../../../../../../platform/hal/port;../../../../../../../../platform/hal/uart;../../../../../../../../platform/hal/pit;../../../../../../../../platform/hal/lpuart;../../../../../../../../platform/drivers/edma;../../../../../../../../platform/drivers/edma/common;../../../../../../../../platform/hal/edma;../../../../../../../../platform/hal/dmamux;../../../../../../../../platform/hal/mcg;../../../../../../../../platform/hal/sim;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/drivers;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/soundcard;../../../../../../../../platform/drivers/sai;../../../../../../../../platform/drivers/sai/common;../../../../../../../../platform/drivers/i2c/i2c_master;../../../../../../../../platform/drivers/i2c/common;../../../../../../../../platform/hal/sai;../../../../../../../../platform/hal/i2c
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/bsp/K22FN512xxx12_flash.scf
  link misc: ../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/bsp/bsp.lib 
../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/psp/psp.lib 
../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/mqx_stdlib/mqx_stdlib.lib 
../../../../../../../../lib/ksdk_mqx_lib/uv4/K22F51212/release/ksdk_mqx_lib.lib 
../../../../../../../usb_core/otg/build/uv4/usbotg_sdk_twrk22f120m_mqx/release/usbotg_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../../../rtos/mqx/lib/twrk22f120m.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove
