# Keil uVision project host_msd_fatfs_frdmk22f120m_ucosiii.uvproj, settings and files
target host_msd_fatfs_frdmk22f120m_ucosiii Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: host_msd_fatfs_ucosiii.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12, KEIL, FRDM_K22F120M, FREEDOM, FSL_RTOS_UCOSIII, USB_DISK_ENABLE=1
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../../../platform/osa;../../../../../../../../rtos;../../../../../../../../platform/utilities;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK22F51212;../../../../../../../../boards/frdmk22f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../../../device/audio/generator;../../../../../../device/audio/speaker;../../../../../../device/audio/speaker/sdk;../../../../../../device/audio/speaker;../../../../../../device/cdc/virtual_com;../../../../../../device/composite/hid_audio;../../../../../../device/composite/msd_cdc;../../../../../../device/hid/hid_keyboard;../../../../../../device/hid/hid_mouse;../../../../../../device/msd;../../../../../../device/phdc/weighscale;../../../../../audio/speaker;../../../../../cdc/cdc_serial;../../../../../cdc/cdc_serial/sdk/serial_bsp;../../../../../hid/keyboard;../../../../../hid/keyboard+mouse;../../../../../hid/mouse;../../../../msd_cmd;../../../../../phdc/11073Manager_Demo;../../../../../../otg/hid/mouse;../../../../../../../usb_core/device/include/frdmk22f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/frdmk22f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/khci_max3353;../../../../../../../usb_core/otg/sources/driver/max3353/bm;../../../../../../../usb_core/otg/sources/driver/max3353/mqx;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/drivers/uart;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/gpio;../../../../../../../../platform/drivers/pit;../../../../../../../../platform/hal/gpio;../../../../../../../../platform/drivers/lpuart;../../../../../../../../platform/drivers/lpuart/common;../../../../../../../../platform/system/clock;../../../../../../../../platform/hal/port;../../../../../../../../platform/hal/uart;../../../../../../../../platform/hal/pit;../../../../../../../../platform/hal/lpuart;../../../../../../../../platform/drivers/edma;../../../../../../../../platform/drivers/edma/common;../../../../../../../../platform/hal/edma;../../../../../../../../platform/hal/dmamux;../../../../../../../../platform/hal/mcg;../../../../../../../../platform/hal/sim;../../../../../../../../rtos/uCOSIII/src/config;../../../../../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../../../../../rtos/uCOSIII/src/uC-CPU;../../../../../../../../rtos/uCOSIII/src/uC-LIB;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/drivers/uart/common;../../../../../../../../platform/drivers/gpio/common;../../../../../../../../platform/drivers/soundcard;../../../../../../../../platform/drivers/sai;../../../../../../../../platform/drivers/sai/common;../../../../../../../../platform/drivers/i2c/i2c_master;../../../../../../../../platform/drivers/i2c/common;../../../../../../../../platform/hal/sai;../../../../../../../../platform/hal/i2c;../../../../../../../../filesystem/fatfs;../../../../../../../../filesystem/fatfs/fsl_usb_disk
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../platform/linker/arm/K22F51212/K22FN512xxx12_flash.scf
  link misc: ../../../../../../../../lib/ksdk_ucosiii_lib/uv4/K22F51212/debug/ksdk_ucosiii_lib.lib 
../../../../../../../usb_core/host/build/uv4/usbh_sdk_frdmk22f120m_ucosiii/debug/usbh_ucosiii.lib 
--remove
  group ucosiii
    ../../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
    ../../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.s
    ../../../../../../../../rtos/uCOSIII/src/config/: os_app_hooks.c
    ../../../../../../../../rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../../../../rtos/uCOSIII/src/uC-CPU/: cpu_core.c
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../../../../../platform/startup/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../../../../../platform/startup/MK22F51212/: system_MK22F51212.c
    ../../../../../../../../platform/startup/: startup.c startup.h
  group board
    ../../../../../../../../boards/frdmk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: main.c
    ../../: msd_fat_demo.c
    ../../../../../../../../filesystem/fatfs/fsl_usb_disk/: msd_diskio.h
    ../../../../../../../../filesystem/fatfs/fsl_usb_disk/src/: msd_diskio.c
  group sources:fatfs
    ../../../../../../../../filesystem/fatfs/: diskio.c diskio.h ffconf.h ff.c ff.h
  group sources:fatfs:option
    ../../../../../../../../filesystem/fatfs/option/: unicode.c
target host_msd_fatfs_frdmk22f120m_ucosiii Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: host_msd_fatfs_ucosiii.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12, KEIL, FRDM_K22F120M, FREEDOM, FSL_RTOS_UCOSIII, USB_DISK_ENABLE=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../../../lib/ksdk_ucosiii_lib/uv4/K22F51212/release/ksdk_ucosiii_lib.lib 
../../../../../../../usb_core/host/build/uv4/usbh_sdk_frdmk22f120m_ucosiii/release/usbh_ucosiii.lib 
--remove
