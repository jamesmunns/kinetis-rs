# IAR project host_cdc_serial_frdmk22f120m_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; IAR; FRDM_K22F120M; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../platform/osa; ../../../../../../../../rtos; ../../../../../../../../platform/utilities; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/startup/MK22F51212; ../../../../../../../../boards/frdmk22f120m; ../../../../../../../adapter/sources; ../../../../../../../adapter/sources/sdk; ../../../../../../device/audio/generator; ../../../../../../device/audio/speaker; ../../../../../../device/audio/speaker/sdk; ../../../../../../device/audio/speaker; ../../../../../../device/cdc/virtual_com; ../../../../../../device/composite/hid_audio; ../../../../../../device/composite/msd_cdc; ../../../../../../device/hid/hid_keyboard; ../../../../../../device/hid/hid_mouse; ../../../../../../device/msd; ../../../../../../device/phdc/weighscale; ../../../../../audio/speaker; ../../..; ../../serial_bsp; ../../../../../hid/keyboard; ../../../../../hid/keyboard+mouse; ../../../../../hid/mouse; ../../../../../msd/msd_cmd; ../../../../../phdc/11073Manager_Demo; ../../../../../../otg/hid/mouse; ../../../../../../../usb_core/device/include/frdmk22f120m; ../../../../../../../usb_core/device/include; ../../../../../../../usb_core/device/sources/classes/audio; ../../../../../../../usb_core/device/sources/classes/cdc; ../../../../../../../usb_core/device/sources/classes/common; ../../../../../../../usb_core/device/sources/classes/composite; ../../../../../../../usb_core/device/sources/classes/hid; ../../../../../../../usb_core/device/sources/classes/include; ../../../../../../../usb_core/device/sources/classes/msd; ../../../../../../../usb_core/device/sources/classes/phdc; ../../../../../../../usb_core/device/sources/controller/khci; ../../../../../../../usb_core/device/sources/controller; ../../../../../../../usb_core/hal; ../../../../../../../usb_core/host/include/frdmk22f120m; ../../../../../../../usb_core/host/include; ../../../../../../../usb_core/host/sources/classes/audio; ../../../../../../../usb_core/host/sources/classes/cdc; ../../../../../../../usb_core/host/sources/classes/hid; ../../../../../../../usb_core/host/sources/classes/hub; ../../../../../../../usb_core/host/sources/classes/msd; ../../../../../../../usb_core/host/sources/classes/phdc; ../../../../../../../usb_core/host/sources/classes/printer; ../../../../../../../usb_core/host/sources/controller/khci; ../../../../../../../usb_core/host/sources/controller; ../../../../../../../usb_core/include; ../../../../../../../usb_core/otg/sources/driver/khci; ../../../../../../../usb_core/otg/sources/driver/khci_max3353; ../../../../../../../usb_core/otg/sources/driver/max3353/bm; ../../../../../../../usb_core/otg/sources/driver/max3353/mqx; ../../../../../../../usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../usb_core/otg/sources/include; ../../../../../../../usb_core/otg/sources/otg; ../../../../../../../../platform/drivers/uart; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/gpio; ../../../../../../../../platform/drivers/pit; ../../../../../../../../platform/hal/gpio; ../../../../../../../../platform/drivers/lpuart; ../../../../../../../../platform/drivers/lpuart/common; ../../../../../../../../platform/system/clock; ../../../../../../../../platform/hal/port; ../../../../../../../../platform/hal/uart; ../../../../../../../../platform/hal/pit; ../../../../../../../../platform/hal/lpuart; ../../../../../../../../platform/drivers/edma; ../../../../../../../../platform/drivers/edma/common; ../../../../../../../../platform/hal/edma; ../../../../../../../../platform/hal/dmamux; ../../../../../../../../platform/hal/mcg; ../../../../../../../../platform/hal/sim; ../../../../../../../../boards/common/sgtl5000; ../../../../../../../../platform/drivers; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/soundcard; ../../../../../../../../platform/drivers/sai; ../../../../../../../../platform/drivers/sai/common; ../../../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../../../platform/drivers/i2c/common; ../../../../../../../../platform/system/interrupt; ../../../../../../../../platform/hal/sai; ../../../../../../../../platform/hal/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_cdc_serial_bm.out
  ILINK.IlinkIcfFile: ../../../../../../../../platform/linker/iar/K22F51212/K22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_platform_lib/iar/K22F51212/debug/ksdk_platform_lib.a; ../../../../../../../usb_core/host/build/iar/usbh_sdk_frdmk22f120m_bm/debug/usbh_bm.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; IAR; FRDM_K22F120M; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_platform_lib/iar/K22F51212/release/ksdk_platform_lib.a; ../../../../../../../usb_core/host/build/iar/usbh_sdk_frdmk22f120m_bm/release/usbh_bm.a
  group startup
    ../../../../../../../../platform/startup/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../../../../platform/startup/MK22F51212/: system_MK22F51212.c
    ../../../../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_debug_console.c
    ../../../../../../../../platform/utilities/: fsl_debug_console.h
  group board
    ../../../../../../../../boards/frdmk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: cdc_serial.c cdc_serial.h usb_host_cdc_io.c usb_host_cdc_io.h
  group sources/serial_bsp
    ../../serial_bsp/: charq.h io_prv.h io_serl_int.h serial.h serinprv.h serl_int.c serl_int_kuart.c serl_kuart.h
